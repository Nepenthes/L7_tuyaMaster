# Keil uVision project L7vTuya_netgateMaster.uvprojx, settings and files
target Zigbee(cc2530)&WIFI(WRG1) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: L7vTuya_netgateMaster
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\usrMain;.\timerActuator;.\dataTransmission;.\bspDrv_devIpt;.\bspDrv_devOpt;.\tuyaSDK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group usrMain
    ./usrMain/: usrMain.c dataManage.c usrAppMethod.c delay.c
  group dataTransmission
    ./dataTransmission/: UART_dataTransfer.c datsProcess_uartZigbee.c datsProcess_uartWifi.c
  group timerActuator
    ./timerActuator/: bussiness_timerHard.c bussiness_timerSoft.c timer_Activing.c
  group bspDrv_devIpt
    ./bspDrv_devIpt/: bspDrv_iptDevice.c
  group tuyaSDK
    ./tuyaSDK/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
